PACKAGECONFIG:remove_rcar-v4x = "wayland"
